v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -10320 -920 -10100 -920 {lab=current}
N -10360 -890 -10360 -660 {lab=current}
N -10280 -920 -10280 -840 {lab=current}
N -10360 -1030 -10360 -950 {lab=supply}
N -10360 -1030 -9790 -1030 {lab=supply}
N -9790 -1030 -9790 -950 {lab=supply}
N -10060 -1030 -10060 -950 {lab=supply}
N -10360 -840 -10280 -840 {lab=current}
N -10170 -990 -10170 -920 {lab=current}
N -10170 -990 -9860 -990 {lab=current}
N -9860 -990 -9860 -920 {lab=current}
N -9860 -920 -9830 -920 {lab=current}
N -10060 -710 -10060 -660 {lab=#net1}
N -10060 -600 -10060 -560 {lab=#net2}
N -10060 -500 -10060 -450 {lab=#net3}
N -10020 -740 -9830 -740 {lab=#net4}
N -10060 -810 -9990 -810 {lab=#net4}
N -9990 -810 -9990 -740 {lab=#net4}
N -9990 -740 -9990 -630 {lab=#net4}
N -10020 -630 -9990 -630 {lab=#net4}
N -9990 -630 -9990 -530 {lab=#net4}
N -10020 -530 -9990 -530 {lab=#net4}
N -9990 -530 -9990 -430 {lab=#net4}
N -10020 -430 -9990 -430 {lab=#net4}
N -9790 -710 -9790 -620 {lab=#net5}
N -9850 -800 -9790 -800 {lab=#net6}
N -9850 -800 -9850 -590 {lab=#net6}
N -9850 -590 -9820 -590 {lab=#net6}
N -9850 -590 -9850 -510 {lab=#net6}
N -9790 -560 -9790 -350 {lab=GND}
N -10060 -190 -9790 -190 {lab=GND}
N -10510 -1030 -10360 -1030 {lab=supply}
N -10510 -1030 -10510 -660 {lab=supply}
N -9790 -590 -9740 -590 {lab=GND}
N -9740 -590 -9740 -350 {lab=GND}
N -9790 -190 -9740 -190 {lab=GND}
N -9790 -740 -9750 -740 {lab=GND}
N -9750 -740 -9740 -740 {lab=GND}
N -9790 -920 -9750 -920 {lab=supply}
N -9750 -1030 -9750 -920 {lab=supply}
N -9790 -1030 -9750 -1030 {lab=supply}
N -10060 -920 -10020 -920 {lab=supply}
N -10020 -1030 -10020 -920 {lab=supply}
N -10400 -920 -10360 -920 {lab=supply}
N -10400 -1030 -10400 -920 {lab=supply}
N -10100 -740 -10060 -740 {lab=GND}
N -10100 -740 -10100 -630 {lab=GND}
N -10100 -630 -10060 -630 {lab=GND}
N -10100 -630 -10100 -350 {lab=GND}
N -10100 -430 -10060 -430 {lab=GND}
N -10100 -530 -10060 -530 {lab=GND}
N -10060 -820 -10060 -770 {lab=#net4}
N -10060 -890 -10060 -880 {lab=#net4}
N -9790 -820 -9790 -800 {lab=#net6}
N -9790 -890 -9790 -880 {lab=#net6}
N -9790 -800 -9790 -770 {lab=#net6}
N -9740 -190 -9430 -190 {lab=GND}
N -9740 -240 -9740 -190 {lab=GND}
N -9790 -350 -9790 -190 {lab=GND}
N -9740 -350 -9740 -240 {lab=GND}
N -8030 -630 -8030 -570 {lab=#net7}
N -8030 -510 -8030 -430 {lab=GND}
N -8030 -660 -7960 -660 {lab=GND}
N -7960 -660 -7960 -540 {lab=GND}
N -8030 -540 -7960 -540 {lab=GND}
N -7970 -660 -7900 -660 {lab=GND}
N -8030 -600 -7900 -600 {lab=#net7}
N -7900 -630 -7900 -600 {lab=#net7}
N -7900 -810 -7900 -690 {lab=op_2}
N -7900 -940 -7900 -870 {lab=op_2}
N -8030 -700 -8030 -690 {lab=op_1}
N -8030 -1040 -8030 -880 {lab=op_1}
N -8030 -370 -8030 -190 {lab=GND}
N -8120 -660 -8070 -660 {lab=#net8}
N -8120 -760 -8120 -660 {lab=#net8}
N -8070 -540 -8070 -460 {lab=#net6}
N -7960 -540 -7960 -190 {lab=GND}
N -8940 -190 -8240 -190 {lab=GND}
N -7850 -760 -7840 -760 {lab=#net9}
N -8830 -460 -8280 -460 {lab=#net6}
N -10060 -400 -10060 -360 {lab=#net10}
N -10100 -330 -10060 -330 {lab=GND}
N -10100 -350 -10100 -330 {lab=GND}
N -10020 -330 -9990 -330 {lab=#net4}
N -9990 -430 -9990 -330 {lab=#net4}
N -10060 -300 -10060 -280 {lab=#net11}
N -10100 -250 -10060 -250 {lab=GND}
N -10100 -330 -10100 -250 {lab=GND}
N -10100 -250 -10100 -190 {lab=GND}
N -10060 -220 -10060 -190 {lab=GND}
N -10020 -250 -9990 -250 {lab=#net4}
N -9990 -330 -9990 -250 {lab=#net4}
N -8240 -190 -8030 -190 {lab=GND}
N -8280 -460 -8070 -460 {lab=#net6}
N -8350 -760 -8350 -190 {lab=GND}
N -8220 -350 -8160 -350 {lab=GND}
N -8160 -350 -8160 -190 {lab=GND}
N -8220 -320 -8220 -190 {lab=GND}
N -8220 -760 -8220 -380 {lab=#net8}
N -7840 -760 -7680 -760 {lab=#net9}
N -7970 -190 -7650 -190 {lab=GND}
N -9690 -800 -8910 -800 {lab=#net4}
N -7850 -760 -7850 -660 {lab=#net9}
N -7860 -660 -7850 -660 {lab=#net9}
N -8320 -760 -8120 -760 {lab=#net8}
N -8030 -880 -8030 -810 {lab=op_1}
N -8030 -810 -8030 -700 {lab=op_1}
N -7900 -870 -7900 -810 {lab=op_2}
N -8500 -840 -7560 -840 {lab=#net4}
N -7560 -840 -7560 -760 {lab=#net4}
N -7620 -760 -7560 -760 {lab=#net4}
N -7780 -350 -7720 -350 {lab=GND}
N -7720 -350 -7720 -190 {lab=GND}
N -7780 -320 -7780 -190 {lab=GND}
N -7780 -760 -7780 -380 {lab=#net9}
N -9870 -690 -9690 -690 {lab=#net4}
N -9710 -800 -9710 -690 {lab=#net4}
N -9710 -800 -9690 -800 {lab=#net4}
N -8030 -190 -7970 -190 {lab=GND}
N -9740 -740 -9740 -590 {lab=GND}
N -10100 -190 -10060 -190 {lab=GND}
N -8030 -430 -8030 -370 {lab=GND}
N -10530 -1200 -10460 -1200 {lab=b8bb}
N -9990 -690 -9870 -690 {lab=#net4}
N -9850 -510 -9540 -510 {lab=#net6}
N -10780 -1200 -10670 -1200 {lab=b8bb}
N -10670 -1200 -10530 -1200 {lab=b8bb}
N -10460 -1200 -10320 -1200 {lab=b8bb}
N -11150 -1200 -11080 -1200 {lab=b8b}
N -11080 -1200 -10990 -1200 {lab=b8b}
N -7650 -820 -7650 -800 {lab=b8b}
N -8350 -820 -8350 -800 {lab=b8bb}
N -11420 -1200 -11360 -1200 {lab=b8}
N -11470 -1200 -11470 -1140 {lab=b8}
N -11470 -1200 -11420 -1200 {lab=b8}
N -9930 -340 -9930 -190 {lab=GND}
N -9870 -340 -9870 -190 {lab=GND}
N -9900 -340 -9900 -190 {lab=GND}
N -9990 -380 -9900 -380 {lab=#net4}
N -9430 -190 -8940 -190 {lab=GND}
N -8910 -800 -8500 -800 {lab=#net4}
N -8500 -840 -8500 -800 {lab=#net4}
N -9690 -690 -8420 -690 {lab=#net4}
N -8420 -760 -8380 -760 {lab=#net4}
N -8420 -760 -8420 -690 {lab=#net4}
N -9540 -510 -8830 -510 {lab=#net6}
N -8830 -510 -8830 -460 {lab=#net6}
N -9860 -450 -9860 -300 {lab=GND}
N -9800 -450 -9800 -300 {lab=GND}
N -9830 -450 -9830 -300 {lab=GND}
N -9830 -510 -9830 -490 {lab=#net6}
N -9860 -300 -9800 -300 {lab=GND}
N -9830 -300 -9830 -190 {lab=GND}
N -7900 -940 -7680 -940 {lab=op_2}
N -8030 -1040 -7700 -1040 {lab=op_1}
N -6990 -630 -6990 -570 {lab=#net12}
N -6990 -510 -6990 -430 {lab=GND}
N -6990 -660 -6920 -660 {lab=GND}
N -6920 -660 -6920 -540 {lab=GND}
N -6990 -540 -6920 -540 {lab=GND}
N -6930 -660 -6860 -660 {lab=GND}
N -6990 -600 -6860 -600 {lab=#net12}
N -6860 -630 -6860 -600 {lab=#net12}
N -6860 -810 -6860 -690 {lab=op_2}
N -6990 -700 -6990 -690 {lab=op_1}
N -6990 -370 -6990 -190 {lab=GND}
N -7080 -660 -7030 -660 {lab=#net13}
N -7080 -760 -7080 -660 {lab=#net13}
N -7030 -540 -7030 -460 {lab=#net6}
N -6920 -540 -6920 -190 {lab=GND}
N -6810 -760 -6800 -760 {lab=#net14}
N -7200 -190 -6990 -190 {lab=GND}
N -7240 -460 -7030 -460 {lab=#net6}
N -7310 -760 -7310 -190 {lab=GND}
N -7180 -350 -7120 -350 {lab=GND}
N -7120 -350 -7120 -190 {lab=GND}
N -7180 -320 -7180 -190 {lab=GND}
N -7180 -760 -7180 -380 {lab=#net13}
N -6800 -760 -6640 -760 {lab=#net14}
N -6610 -760 -6610 -190 {lab=GND}
N -6930 -190 -6610 -190 {lab=GND}
N -6810 -760 -6810 -660 {lab=#net14}
N -6820 -660 -6810 -660 {lab=#net14}
N -7280 -760 -7080 -760 {lab=#net13}
N -6990 -880 -6990 -810 {lab=op_1}
N -6990 -810 -6990 -700 {lab=op_1}
N -6860 -870 -6860 -810 {lab=op_2}
N -7460 -840 -6520 -840 {lab=#net4}
N -6520 -840 -6520 -760 {lab=#net4}
N -6580 -760 -6520 -760 {lab=#net4}
N -6740 -350 -6680 -350 {lab=GND}
N -6680 -350 -6680 -190 {lab=GND}
N -6740 -320 -6740 -190 {lab=GND}
N -6740 -760 -6740 -380 {lab=#net14}
N -6990 -190 -6930 -190 {lab=GND}
N -6990 -430 -6990 -370 {lab=GND}
N -6610 -820 -6610 -800 {lab=b7b}
N -7310 -820 -7310 -800 {lab=b7bb}
N -7380 -760 -7340 -760 {lab=#net4}
N -7650 -760 -7650 -190 {lab=GND}
N -7650 -190 -7310 -190 {lab=GND}
N -7310 -190 -7200 -190 {lab=GND}
N -8070 -460 -7240 -460 {lab=#net6}
N -7560 -760 -7380 -760 {lab=#net4}
N -7560 -840 -7460 -840 {lab=#net4}
N -7700 -1040 -6880 -1040 {lab=op_1}
N -7680 -940 -6860 -940 {lab=op_2}
N -6990 -1040 -6990 -880 {lab=op_1}
N -6860 -940 -6860 -870 {lab=op_2}
N -10520 -1440 -10450 -1440 {lab=b7bb}
N -10770 -1440 -10660 -1440 {lab=b7bb}
N -10660 -1440 -10520 -1440 {lab=b7bb}
N -10450 -1440 -10310 -1440 {lab=b7bb}
N -11140 -1440 -11070 -1440 {lab=b7b}
N -11070 -1440 -10980 -1440 {lab=b7b}
N -11410 -1440 -11350 -1440 {lab=b7}
N -11460 -1440 -11460 -1380 {lab=b7}
N -11460 -1440 -11410 -1440 {lab=b7}
N -6050 -630 -6050 -570 {lab=#net15}
N -6050 -510 -6050 -430 {lab=GND}
N -6050 -660 -5980 -660 {lab=GND}
N -5980 -660 -5980 -540 {lab=GND}
N -6050 -540 -5980 -540 {lab=GND}
N -5990 -660 -5920 -660 {lab=GND}
N -6050 -600 -5920 -600 {lab=#net15}
N -5920 -630 -5920 -600 {lab=#net15}
N -5920 -810 -5920 -690 {lab=op_2}
N -6050 -700 -6050 -690 {lab=op_1}
N -6050 -370 -6050 -190 {lab=GND}
N -6140 -660 -6090 -660 {lab=#net16}
N -6140 -760 -6140 -660 {lab=#net16}
N -6090 -540 -6090 -460 {lab=#net6}
N -5980 -540 -5980 -190 {lab=GND}
N -5870 -760 -5860 -760 {lab=#net17}
N -6260 -190 -6050 -190 {lab=GND}
N -6300 -460 -6090 -460 {lab=#net6}
N -6370 -760 -6370 -190 {lab=GND}
N -6240 -350 -6180 -350 {lab=GND}
N -6180 -350 -6180 -190 {lab=GND}
N -6240 -320 -6240 -190 {lab=GND}
N -6240 -760 -6240 -380 {lab=#net16}
N -5860 -760 -5700 -760 {lab=#net17}
N -5670 -760 -5670 -190 {lab=GND}
N -5990 -190 -5670 -190 {lab=GND}
N -5870 -760 -5870 -660 {lab=#net17}
N -5880 -660 -5870 -660 {lab=#net17}
N -6340 -760 -6140 -760 {lab=#net16}
N -6050 -880 -6050 -810 {lab=op_1}
N -6050 -810 -6050 -700 {lab=op_1}
N -5920 -870 -5920 -810 {lab=op_2}
N -6520 -840 -5580 -840 {lab=#net4}
N -5580 -840 -5580 -760 {lab=#net4}
N -5640 -760 -5580 -760 {lab=#net4}
N -5800 -350 -5740 -350 {lab=GND}
N -5740 -350 -5740 -190 {lab=GND}
N -5800 -320 -5800 -190 {lab=GND}
N -5800 -760 -5800 -380 {lab=#net17}
N -6050 -190 -5990 -190 {lab=GND}
N -6050 -430 -6050 -370 {lab=GND}
N -5670 -820 -5670 -800 {lab=b6b}
N -6370 -820 -6370 -800 {lab=b6bb}
N -6440 -760 -6400 -760 {lab=#net4}
N -6370 -190 -6260 -190 {lab=GND}
N -6520 -760 -6440 -760 {lab=#net4}
N -5920 -940 -5920 -870 {lab=op_2}
N -6880 -1040 -5940 -1040 {lab=op_1}
N -6860 -940 -5920 -940 {lab=op_2}
N -6050 -1040 -6050 -880 {lab=op_1}
N -7030 -460 -6300 -460 {lab=#net6}
N -6610 -190 -6370 -190 {lab=GND}
N -10530 -1750 -10460 -1750 {lab=b6bb}
N -10780 -1750 -10670 -1750 {lab=b6bb}
N -10670 -1750 -10530 -1750 {lab=b6bb}
N -10460 -1750 -10320 -1750 {lab=b6bb}
N -11150 -1750 -11080 -1750 {lab=b6b}
N -11080 -1750 -10990 -1750 {lab=b6b}
N -11420 -1750 -11360 -1750 {lab=b6}
N -11470 -1750 -11470 -1690 {lab=b6}
N -11470 -1750 -11420 -1750 {lab=b6}
N -5110 -630 -5110 -570 {lab=#net18}
N -5110 -510 -5110 -430 {lab=GND}
N -5110 -660 -5040 -660 {lab=GND}
N -5040 -660 -5040 -540 {lab=GND}
N -5110 -540 -5040 -540 {lab=GND}
N -5050 -660 -4980 -660 {lab=GND}
N -5110 -600 -4980 -600 {lab=#net18}
N -4980 -630 -4980 -600 {lab=#net18}
N -4980 -810 -4980 -690 {lab=op_2}
N -5110 -700 -5110 -690 {lab=op_1}
N -5110 -370 -5110 -190 {lab=GND}
N -5200 -660 -5150 -660 {lab=#net19}
N -5200 -760 -5200 -660 {lab=#net19}
N -5150 -540 -5150 -460 {lab=#net6}
N -5040 -540 -5040 -190 {lab=GND}
N -4930 -760 -4920 -760 {lab=#net20}
N -5320 -190 -5110 -190 {lab=GND}
N -5360 -460 -5150 -460 {lab=#net6}
N -5430 -760 -5430 -190 {lab=GND}
N -5300 -350 -5240 -350 {lab=GND}
N -5240 -350 -5240 -190 {lab=GND}
N -5300 -320 -5300 -190 {lab=GND}
N -5300 -760 -5300 -380 {lab=#net19}
N -4920 -760 -4760 -760 {lab=#net20}
N -4730 -760 -4730 -190 {lab=GND}
N -5050 -190 -4730 -190 {lab=GND}
N -4930 -760 -4930 -660 {lab=#net20}
N -4940 -660 -4930 -660 {lab=#net20}
N -5400 -760 -5200 -760 {lab=#net19}
N -5110 -810 -5110 -700 {lab=op_1}
N -4980 -870 -4980 -810 {lab=op_2}
N -5580 -840 -4640 -840 {lab=#net4}
N -4640 -840 -4640 -760 {lab=#net4}
N -4700 -760 -4640 -760 {lab=#net4}
N -4860 -350 -4800 -350 {lab=GND}
N -4800 -350 -4800 -190 {lab=GND}
N -4860 -320 -4860 -190 {lab=GND}
N -4860 -760 -4860 -380 {lab=#net20}
N -5110 -190 -5050 -190 {lab=GND}
N -5110 -430 -5110 -370 {lab=GND}
N -4730 -820 -4730 -800 {lab=b5b}
N -5430 -820 -5430 -800 {lab=b5bb}
N -5500 -760 -5460 -760 {lab=#net4}
N -5430 -190 -5320 -190 {lab=GND}
N -5580 -760 -5500 -760 {lab=#net4}
N -5940 -1040 -5000 -1040 {lab=op_1}
N -5920 -940 -4980 -940 {lab=op_2}
N -4980 -940 -4980 -870 {lab=op_2}
N -5110 -1040 -5110 -810 {lab=op_1}
N -6090 -460 -5360 -460 {lab=#net6}
N -5670 -190 -5430 -190 {lab=GND}
N -10540 -2030 -10470 -2030 {lab=b5bb}
N -10790 -2030 -10680 -2030 {lab=b5bb}
N -10680 -2030 -10540 -2030 {lab=b5bb}
N -10470 -2030 -10330 -2030 {lab=b5bb}
N -11160 -2030 -11090 -2030 {lab=b5b}
N -11090 -2030 -11000 -2030 {lab=b5b}
N -11430 -2030 -11370 -2030 {lab=b5}
N -11480 -2030 -11480 -1970 {lab=b5}
N -11480 -2030 -11430 -2030 {lab=b5}
N -4000 -630 -4000 -570 {lab=#net21}
N -4000 -510 -4000 -430 {lab=GND}
N -4000 -660 -3930 -660 {lab=GND}
N -3930 -660 -3930 -540 {lab=GND}
N -4000 -540 -3930 -540 {lab=GND}
N -3940 -660 -3870 -660 {lab=GND}
N -4000 -600 -3870 -600 {lab=#net21}
N -3870 -630 -3870 -600 {lab=#net21}
N -4000 -370 -4000 -190 {lab=GND}
N -4090 -660 -4040 -660 {lab=#net22}
N -4090 -760 -4090 -660 {lab=#net22}
N -4040 -540 -4040 -460 {lab=#net6}
N -3930 -540 -3930 -190 {lab=GND}
N -3820 -760 -3810 -760 {lab=#net23}
N -4210 -190 -4000 -190 {lab=GND}
N -4250 -460 -4040 -460 {lab=#net6}
N -4320 -760 -4320 -190 {lab=GND}
N -4190 -350 -4130 -350 {lab=GND}
N -4130 -350 -4130 -190 {lab=GND}
N -4190 -320 -4190 -190 {lab=GND}
N -4190 -760 -4190 -380 {lab=#net22}
N -3810 -760 -3650 -760 {lab=#net23}
N -3620 -760 -3620 -190 {lab=GND}
N -3940 -190 -3620 -190 {lab=GND}
N -3820 -760 -3820 -660 {lab=#net23}
N -3830 -660 -3820 -660 {lab=#net23}
N -4290 -760 -4090 -760 {lab=#net22}
N -4470 -840 -3530 -840 {lab=#net4}
N -3530 -840 -3530 -760 {lab=#net4}
N -3590 -760 -3530 -760 {lab=#net4}
N -3750 -350 -3690 -350 {lab=GND}
N -3690 -350 -3690 -190 {lab=GND}
N -3750 -320 -3750 -190 {lab=GND}
N -3750 -760 -3750 -380 {lab=#net23}
N -4000 -190 -3940 -190 {lab=GND}
N -4000 -430 -4000 -370 {lab=GND}
N -3620 -820 -3620 -800 {lab=b4b}
N -4320 -820 -4320 -800 {lab=b4bb}
N -4390 -760 -4350 -760 {lab=#net4}
N -4320 -190 -4210 -190 {lab=GND}
N -4470 -760 -4390 -760 {lab=#net4}
N -5150 -460 -4250 -460 {lab=#net6}
N -4730 -190 -4320 -190 {lab=GND}
N -4640 -840 -4470 -840 {lab=#net4}
N -5000 -1040 -3300 -1040 {lab=op_1}
N -4980 -940 -3280 -940 {lab=op_2}
N -4000 -1040 -4000 -690 {lab=op_1}
N -3870 -940 -3870 -690 {lab=op_2}
N -4640 -760 -4470 -760 {lab=#net4}
N -10550 -2270 -10480 -2270 {lab=b4bb}
N -10800 -2270 -10690 -2270 {lab=b4bb}
N -10690 -2270 -10550 -2270 {lab=b4bb}
N -10480 -2270 -10340 -2270 {lab=b4bb}
N -11170 -2270 -11100 -2270 {lab=b4b}
N -11100 -2270 -11010 -2270 {lab=b4b}
N -11440 -2270 -11380 -2270 {lab=b4}
N -11490 -2270 -11490 -2210 {lab=b4}
N -11490 -2270 -11440 -2270 {lab=b4}
N -2950 -630 -2950 -570 {lab=#net24}
N -2950 -510 -2950 -430 {lab=GND}
N -2950 -660 -2880 -660 {lab=GND}
N -2880 -660 -2880 -540 {lab=GND}
N -2950 -540 -2880 -540 {lab=GND}
N -2890 -660 -2820 -660 {lab=GND}
N -2950 -600 -2820 -600 {lab=#net24}
N -2820 -630 -2820 -600 {lab=#net24}
N -2950 -370 -2950 -190 {lab=GND}
N -3040 -660 -2990 -660 {lab=#net25}
N -3040 -760 -3040 -660 {lab=#net25}
N -2990 -540 -2990 -460 {lab=#net6}
N -2880 -540 -2880 -190 {lab=GND}
N -2770 -760 -2760 -760 {lab=#net26}
N -3160 -190 -2950 -190 {lab=GND}
N -3200 -460 -2990 -460 {lab=#net6}
N -3270 -760 -3270 -190 {lab=GND}
N -3140 -350 -3080 -350 {lab=GND}
N -3080 -350 -3080 -190 {lab=GND}
N -3140 -320 -3140 -190 {lab=GND}
N -3140 -760 -3140 -380 {lab=#net25}
N -2760 -760 -2600 -760 {lab=#net26}
N -2570 -760 -2570 -190 {lab=GND}
N -2890 -190 -2570 -190 {lab=GND}
N -2770 -760 -2770 -660 {lab=#net26}
N -2780 -660 -2770 -660 {lab=#net26}
N -3240 -760 -3040 -760 {lab=#net25}
N -3420 -840 -2480 -840 {lab=#net4}
N -2480 -840 -2480 -760 {lab=#net4}
N -2540 -760 -2480 -760 {lab=#net4}
N -2700 -350 -2640 -350 {lab=GND}
N -2640 -350 -2640 -190 {lab=GND}
N -2700 -320 -2700 -190 {lab=GND}
N -2700 -760 -2700 -380 {lab=#net26}
N -2950 -190 -2890 -190 {lab=GND}
N -2950 -430 -2950 -370 {lab=GND}
N -2570 -820 -2570 -800 {lab=b3b}
N -3270 -820 -3270 -800 {lab=b3bb}
N -3340 -760 -3300 -760 {lab=#net4}
N -3270 -190 -3160 -190 {lab=GND}
N -3420 -760 -3340 -760 {lab=#net4}
N -4040 -460 -3200 -460 {lab=#net6}
N -3620 -190 -3270 -190 {lab=GND}
N -3530 -840 -3420 -840 {lab=#net4}
N -3530 -760 -3420 -760 {lab=#net4}
N -690 -940 -250 -940 {lab=op_2}
N -460 -1040 -250 -1040 {lab=op_1}
N -680 -1040 -520 -1040 {lab=op_1}
N -720 -940 -690 -940 {lab=op_2}
N -3300 -1040 -2370 -1040 {lab=op_1}
N -3280 -940 -2350 -940 {lab=op_2}
N -2950 -1040 -2950 -690 {lab=op_1}
N -2820 -940 -2820 -690 {lab=op_2}
N -10540 -2500 -10470 -2500 {lab=b3bb}
N -10790 -2500 -10680 -2500 {lab=b3bb}
N -10680 -2500 -10540 -2500 {lab=b3bb}
N -10470 -2500 -10330 -2500 {lab=b3bb}
N -11160 -2500 -11090 -2500 {lab=b3b}
N -11090 -2500 -11000 -2500 {lab=b3b}
N -11430 -2500 -11370 -2500 {lab=b3}
N -11480 -2500 -11480 -2440 {lab=b3}
N -11480 -2500 -11430 -2500 {lab=b3}
N -1970 -650 -1970 -620 {lab=#net27}
N -1970 -680 -1880 -680 {lab=GND}
N -2040 -590 -2010 -590 {lab=#net6}
N -2040 -590 -2040 -500 {lab=#net6}
N -1970 -590 -1880 -590 {lab=GND}
N -1880 -680 -1810 -680 {lab=GND}
N -1970 -640 -1810 -640 {lab=#net27}
N -1810 -650 -1810 -640 {lab=#net27}
N -1700 -350 -1640 -350 {lab=GND}
N -1640 -350 -1640 -190 {lab=GND}
N -1700 -320 -1700 -190 {lab=GND}
N -1750 -350 -1740 -350 {lab=b2bb}
N -1600 -820 -1600 -800 {lab=b2b}
N -2480 -760 -2380 -760 {lab=#net4}
N -2320 -760 -2090 -760 {lab=#net28}
N -2090 -760 -2090 -680 {lab=#net28}
N -2090 -680 -2010 -680 {lab=#net28}
N -1880 -590 -1880 -500 {lab=GND}
N -1880 -440 -1880 -190 {lab=GND}
N -2570 -190 -1880 -190 {lab=GND}
N -2230 -350 -2170 -350 {lab=GND}
N -2170 -350 -2170 -190 {lab=GND}
N -2230 -320 -2230 -190 {lab=GND}
N -2230 -760 -2230 -380 {lab=#net28}
N -2990 -460 -2040 -460 {lab=#net6}
N -1880 -190 -1700 -190 {lab=GND}
N -1700 -190 -1640 -190 {lab=GND}
N -1640 -190 -1600 -190 {lab=GND}
N -1770 -680 -1740 -680 {lab=#net29}
N -1740 -760 -1740 -680 {lab=#net29}
N -1740 -760 -1630 -760 {lab=#net29}
N -1700 -760 -1700 -380 {lab=#net29}
N -1600 -760 -1600 -190 {lab=GND}
N -2290 -350 -2270 -350 {lab=b2b}
N -2350 -820 -2350 -800 {lab=b2bb}
N -2480 -840 -1430 -840 {lab=#net4}
N -1430 -840 -1430 -760 {lab=#net4}
N -1570 -760 -1430 -760 {lab=#net4}
N -1970 -410 -1970 -190 {lab=GND}
N -2370 -1040 -1790 -1040 {lab=op_1}
N -2350 -940 -1770 -940 {lab=op_2}
N -1970 -1040 -1970 -710 {lab=op_1}
N -1810 -940 -1810 -710 {lab=op_2}
N -10540 -2740 -10470 -2740 {lab=b2bb}
N -10790 -2740 -10680 -2740 {lab=b2bb}
N -10680 -2740 -10540 -2740 {lab=b2bb}
N -10470 -2740 -10330 -2740 {lab=b2bb}
N -11160 -2740 -11090 -2740 {lab=b2b}
N -11090 -2740 -11000 -2740 {lab=b2b}
N -11430 -2740 -11370 -2740 {lab=b2}
N -11480 -2740 -11480 -2680 {lab=b2}
N -11480 -2740 -11430 -2740 {lab=b2}
N -2350 -760 -2350 -190 {lab=GND}
N -890 -650 -890 -620 {lab=#net30}
N -890 -680 -800 -680 {lab=GND}
N -890 -500 -890 -470 {lab=#net31}
N -890 -620 -890 -560 {lab=#net30}
N -960 -530 -930 -530 {lab=#net6}
N -960 -440 -930 -440 {lab=#net6}
N -960 -530 -960 -440 {lab=#net6}
N -890 -530 -800 -530 {lab=GND}
N -890 -440 -800 -440 {lab=GND}
N -800 -680 -730 -680 {lab=GND}
N -890 -640 -730 -640 {lab=#net30}
N -730 -650 -730 -640 {lab=#net30}
N -620 -350 -560 -350 {lab=GND}
N -560 -350 -560 -190 {lab=GND}
N -620 -320 -620 -190 {lab=GND}
N -670 -350 -660 -350 {lab=b1bb}
N -520 -820 -520 -800 {lab=b1b}
N -1400 -760 -1300 -760 {lab=#net4}
N -1240 -760 -1010 -760 {lab=#net32}
N -1010 -760 -1010 -680 {lab=#net32}
N -1010 -680 -930 -680 {lab=#net32}
N -800 -680 -800 -530 {lab=GND}
N -800 -530 -800 -440 {lab=GND}
N -1150 -350 -1090 -350 {lab=GND}
N -1090 -350 -1090 -190 {lab=GND}
N -1150 -320 -1150 -190 {lab=GND}
N -1150 -760 -1150 -380 {lab=#net32}
N -800 -190 -620 -190 {lab=GND}
N -620 -190 -560 -190 {lab=GND}
N -560 -190 -520 -190 {lab=GND}
N -690 -680 -660 -680 {lab=#net33}
N -660 -760 -660 -680 {lab=#net33}
N -660 -760 -550 -760 {lab=#net33}
N -620 -760 -620 -380 {lab=#net33}
N -520 -760 -520 -190 {lab=GND}
N -1210 -350 -1190 -350 {lab=b1b}
N -1270 -820 -1270 -800 {lab=b1bb}
N -1400 -840 -350 -840 {lab=#net4}
N -350 -840 -350 -760 {lab=#net4}
N -490 -760 -350 -760 {lab=#net4}
N -1270 -760 -1270 -190 {lab=GND}
N -1600 -190 -1270 -190 {lab=GND}
N -1270 -190 -1150 -190 {lab=GND}
N -1150 -190 -1090 -190 {lab=GND}
N -1090 -190 -890 -190 {lab=GND}
N -890 -190 -800 -190 {lab=GND}
N -890 -320 -890 -290 {lab=#net34}
N -960 -350 -930 -350 {lab=#net6}
N -960 -260 -930 -260 {lab=#net6}
N -960 -350 -960 -260 {lab=#net6}
N -890 -350 -800 -350 {lab=GND}
N -890 -260 -800 -260 {lab=GND}
N -800 -350 -800 -260 {lab=GND}
N -890 -410 -890 -380 {lab=#net35}
N -890 -230 -890 -190 {lab=GND}
N -800 -440 -800 -350 {lab=GND}
N -800 -260 -800 -190 {lab=GND}
N -960 -440 -960 -350 {lab=#net6}
N -1970 -560 -1970 -530 {lab=#net36}
N -1970 -500 -1880 -500 {lab=GND}
N -1880 -500 -1880 -440 {lab=GND}
N -1970 -470 -1970 -410 {lab=GND}
N -2040 -500 -2010 -500 {lab=#net6}
N -2040 -500 -2040 -460 {lab=#net6}
N -1880 -680 -1880 -590 {lab=GND}
N -2040 -460 -960 -460 {lab=#net6}
N -1430 -840 -1400 -840 {lab=#net4}
N -1430 -760 -1400 -760 {lab=#net4}
N -1790 -1040 -740 -1040 {lab=op_1}
N -1770 -940 -720 -940 {lab=op_2}
N -890 -1040 -890 -710 {lab=op_1}
N -730 -940 -730 -710 {lab=op_2}
N -10540 -3000 -10470 -3000 {lab=b1bb}
N -10790 -3000 -10680 -3000 {lab=b1bb}
N -10680 -3000 -10540 -3000 {lab=b1bb}
N -10470 -3000 -10330 -3000 {lab=b1bb}
N -11160 -3000 -11090 -3000 {lab=b1b}
N -11090 -3000 -11000 -3000 {lab=b1b}
N -11430 -3000 -11370 -3000 {lab=b1}
N -11480 -3000 -11480 -2940 {lab=b1}
N -11480 -3000 -11430 -3000 {lab=b1}
N -740 -1040 -680 -1040 {lab=op_1}
N -10060 -880 -10060 -820 {lab=#net4}
N -9790 -880 -9790 -820 {lab=#net6}
N -520 -1040 -460 -1040 {lab=op_1}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -10340 -920 0 1 {name=M10
L=3
W=2.2
nf=1 mult=3
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -10040 -740 0 1 {name=M2
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -10080 -920 0 0 {name=M1
L=3
W=2.2
nf=1 mult=3
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -9810 -920 0 0 {name=M3
L=3
W=2.2
nf=1 mult=3
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -9810 -740 0 0 {name=M4
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -9810 -590 0 0 {name=M5
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -10040 -630 0 1 {name=M6
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -10040 -530 0 1 {name=M7
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -10040 -430 0 1 {name=M8
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8050 -660 0 0 {name=M35
L=0.5
W=2.2
nf=1 mult=32
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8050 -540 0 0 {name=M36
L=3
W=2.2
nf=1 mult=32
model=nfet_01v8
spiceprefix=X
id=@m23[id]
gm=@m23[gm]}
C {sky130_fd_pr/nfet_01v8.sym} -7880 -660 0 1 {name=M37
L=0.5
W=2.2
nf=1 mult=32
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -10040 -330 0 1 {name=M38
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -10040 -250 0 1 {name=M39
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8350 -780 1 0 {name=M67
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8240 -350 0 0 {name=M69
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7650 -780 1 0 {name=M70
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7800 -350 0 0 {name=M71
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {gnd.sym} -9930 -190 0 0 {name=l1 lab=GND}
C {lab_pin.sym} -10320 -1200 0 0 {name=p14 sig_type=std_logic lab=b8bb}
C {lab_pin.sym} -11040 -1200 0 0 {name=p17 sig_type=std_logic lab=b8b}
C {inverter1.sym} -10570 -1000 0 0 {name=x15}
C {inverter1.sym} -10940 -1000 0 0 {name=x16}
C {lab_pin.sym} -8350 -820 0 0 {name=p56 sig_type=std_logic lab=b8bb}
C {lab_pin.sym} -8260 -350 0 0 {name=p57 sig_type=std_logic lab=b8b}
C {lab_pin.sym} -7650 -820 0 0 {name=p58 sig_type=std_logic lab=b8b}
C {lab_pin.sym} -7820 -350 0 0 {name=p59 sig_type=std_logic lab=b8bb}
C {sky130_fd_pr/nfet_01v8.sym} -9900 -360 1 0 {name=M72
L=2.2
W=2.2
nf=1 mult=10
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -9830 -470 1 0 {name=M24
L=2.2
W=2.2
nf=1 mult=10
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7010 -660 0 0 {name=M9
L=0.5
W=2.2
nf=1 mult=16
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7010 -540 0 0 {name=M11
L=3
W=2.2
nf=1 mult=16
model=nfet_01v8
spiceprefix=X
id=@m23[id]
gm=@m23[gm]}
C {sky130_fd_pr/nfet_01v8.sym} -6840 -660 0 1 {name=M12
L=0.5
W=2.2
nf=1 mult=16
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7310 -780 1 0 {name=M13
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7200 -350 0 0 {name=M14
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6610 -780 1 0 {name=M15
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6760 -350 0 0 {name=M16
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -7310 -820 0 0 {name=p1 sig_type=std_logic lab=b7bb}
C {lab_pin.sym} -7220 -350 0 0 {name=p2 sig_type=std_logic lab=b7b}
C {lab_pin.sym} -6610 -820 0 0 {name=p4 sig_type=std_logic lab=b7b}
C {lab_pin.sym} -6780 -350 0 0 {name=p5 sig_type=std_logic lab=b7bb}
C {lab_pin.sym} -10310 -1440 0 0 {name=p6 sig_type=std_logic lab=b7bb}
C {lab_pin.sym} -11030 -1440 0 0 {name=p7 sig_type=std_logic lab=b7b}
C {inverter1.sym} -10560 -1240 0 0 {name=x1}
C {inverter1.sym} -10930 -1240 0 0 {name=x2}
C {sky130_fd_pr/nfet_01v8.sym} -6070 -660 0 0 {name=M17
L=0.5
W=2.2
nf=1 mult=8
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6070 -540 0 0 {name=M18
L=3
W=2.2
nf=1 mult=8
model=nfet_01v8
spiceprefix=X
id=@m23[id]
gm=@m23[gm]}
C {sky130_fd_pr/nfet_01v8.sym} -5900 -660 0 1 {name=M19
L=0.5
W=2.2
nf=1 mult=8
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6370 -780 1 0 {name=M20
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6260 -350 0 0 {name=M21
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5670 -780 1 0 {name=M22
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5820 -350 0 0 {name=M23
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -6370 -820 0 0 {name=p8 sig_type=std_logic lab=b6bb}
C {lab_pin.sym} -6280 -350 0 0 {name=p9 sig_type=std_logic lab=b6b}
C {lab_pin.sym} -5670 -820 0 0 {name=p10 sig_type=std_logic lab=b6b}
C {lab_pin.sym} -5840 -350 0 0 {name=p11 sig_type=std_logic lab=b6bb}
C {lab_pin.sym} -10320 -1750 0 0 {name=p12 sig_type=std_logic lab=b6bb}
C {lab_pin.sym} -11040 -1750 0 0 {name=p13 sig_type=std_logic lab=b6b}
C {inverter1.sym} -10570 -1550 0 0 {name=x3}
C {inverter1.sym} -10940 -1550 0 0 {name=x4}
C {sky130_fd_pr/nfet_01v8.sym} -5130 -660 0 0 {name=M25
L=0.5
W=2.2
nf=1 mult=4
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5130 -540 0 0 {name=M26
L=3
W=2.2
nf=1 mult=4
model=nfet_01v8
spiceprefix=X
id=@m23[id]
gm=@m23[gm]}
C {sky130_fd_pr/nfet_01v8.sym} -4960 -660 0 1 {name=M27
L=0.5
W=2.2
nf=1 mult=4
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5430 -780 1 0 {name=M28
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5320 -350 0 0 {name=M29
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4730 -780 1 0 {name=M30
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4880 -350 0 0 {name=M31
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -5430 -820 0 0 {name=p15 sig_type=std_logic lab=b5bb}
C {lab_pin.sym} -5340 -350 0 0 {name=p16 sig_type=std_logic lab=b5b}
C {lab_pin.sym} -4730 -820 0 0 {name=p18 sig_type=std_logic lab=b5b}
C {lab_pin.sym} -4900 -350 0 0 {name=p19 sig_type=std_logic lab=b5bb}
C {lab_pin.sym} -10330 -2030 0 0 {name=p20 sig_type=std_logic lab=b5bb}
C {lab_pin.sym} -11050 -2030 0 0 {name=p21 sig_type=std_logic lab=b5b}
C {inverter1.sym} -10580 -1830 0 0 {name=x5}
C {inverter1.sym} -10950 -1830 0 0 {name=x6}
C {sky130_fd_pr/nfet_01v8.sym} -4020 -660 0 0 {name=M32
L=0.5
W=2.2
nf=1 mult=2
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4020 -540 0 0 {name=M33
L=3
W=2.2
nf=1 mult=2
model=nfet_01v8
spiceprefix=X
id=@m23[id]
gm=@m23[gm]}
C {sky130_fd_pr/nfet_01v8.sym} -3850 -660 0 1 {name=M34
L=0.5
W=2.2
nf=1 mult=2
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4320 -780 1 0 {name=M40
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4210 -350 0 0 {name=M41
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -3620 -780 1 0 {name=M42
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -3770 -350 0 0 {name=M43
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -4320 -820 0 0 {name=p22 sig_type=std_logic lab=b4bb}
C {lab_pin.sym} -4230 -350 0 0 {name=p23 sig_type=std_logic lab=b4b}
C {lab_pin.sym} -3620 -820 0 0 {name=p24 sig_type=std_logic lab=b4b}
C {lab_pin.sym} -3790 -350 0 0 {name=p25 sig_type=std_logic lab=b4bb}
C {lab_pin.sym} -10340 -2270 0 0 {name=p26 sig_type=std_logic lab=b4bb}
C {lab_pin.sym} -11060 -2270 0 0 {name=p27 sig_type=std_logic lab=b4b}
C {inverter1.sym} -10590 -2070 0 0 {name=x7}
C {inverter1.sym} -10960 -2070 0 0 {name=x8}
C {sky130_fd_pr/nfet_01v8.sym} -2970 -660 0 0 {name=M44
L=0.5
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -2970 -540 0 0 {name=M45
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
id=@m23[id]
gm=@m23[gm]}
C {sky130_fd_pr/nfet_01v8.sym} -2800 -660 0 1 {name=M46
L=0.5
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -3270 -780 1 0 {name=M47
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -3160 -350 0 0 {name=M48
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -2570 -780 1 0 {name=M49
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -2720 -350 0 0 {name=M50
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -3270 -820 0 0 {name=p28 sig_type=std_logic lab=b3bb}
C {lab_pin.sym} -3180 -350 0 0 {name=p29 sig_type=std_logic lab=b3b}
C {lab_pin.sym} -2570 -820 0 0 {name=p30 sig_type=std_logic lab=b3b}
C {lab_pin.sym} -2740 -350 0 0 {name=p31 sig_type=std_logic lab=b3bb}
C {lab_pin.sym} -10330 -2500 0 0 {name=p32 sig_type=std_logic lab=b3bb}
C {lab_pin.sym} -11050 -2500 0 0 {name=p33 sig_type=std_logic lab=b3b}
C {inverter1.sym} -10580 -2300 0 0 {name=x9}
C {inverter1.sym} -10950 -2300 0 0 {name=x10}
C {sky130_fd_pr/nfet_01v8.sym} -1990 -680 0 0 {name=M51
L=0.5
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1990 -500 0 0 {name=M52
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1990 -590 0 0 {name=M53
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1790 -680 0 1 {name=M54
L=0.5
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -2350 -780 1 0 {name=M55
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1600 -780 1 0 {name=M57
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1720 -350 0 0 {name=M58
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -2350 -820 0 0 {name=p34 sig_type=std_logic lab=b2bb}
C {lab_pin.sym} -1750 -350 0 0 {name=p36 sig_type=std_logic lab=b2bb}
C {lab_pin.sym} -1600 -820 0 0 {name=p37 sig_type=std_logic lab=b2b}
C {sky130_fd_pr/nfet_01v8.sym} -2250 -350 0 0 {name=M56
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -2290 -350 0 0 {name=p35 sig_type=std_logic lab=b2b}
C {lab_pin.sym} -10330 -2740 0 0 {name=p38 sig_type=std_logic lab=b2bb}
C {lab_pin.sym} -11050 -2740 0 0 {name=p39 sig_type=std_logic lab=b2b}
C {inverter1.sym} -10580 -2540 0 0 {name=x11}
C {inverter1.sym} -10950 -2540 0 0 {name=x12}
C {sky130_fd_pr/nfet_01v8.sym} -910 -680 0 0 {name=M59
L=0.5
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -910 -440 0 0 {name=M60
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -910 -530 0 0 {name=M61
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -710 -680 0 1 {name=M62
L=0.5
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -1270 -780 1 0 {name=M63
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -520 -780 1 0 {name=M64
L=0.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -640 -350 0 0 {name=M65
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -1270 -820 0 0 {name=p40 sig_type=std_logic lab=b1bb}
C {lab_pin.sym} -670 -350 0 0 {name=p41 sig_type=std_logic lab=b1bb}
C {lab_pin.sym} -520 -820 0 0 {name=p42 sig_type=std_logic lab=b1b}
C {sky130_fd_pr/nfet_01v8.sym} -1170 -350 0 0 {name=M66
L=1.2
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -1210 -350 0 0 {name=p43 sig_type=std_logic lab=b1b}
C {sky130_fd_pr/nfet_01v8.sym} -910 -260 0 0 {name=M68
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -910 -350 0 0 {name=M73
L=3
W=2.2
nf=1 mult=1
model=nfet_01v8
spiceprefix=X
}
C {lab_pin.sym} -10330 -3000 0 0 {name=p44 sig_type=std_logic lab=b1bb}
C {lab_pin.sym} -11050 -3000 0 0 {name=p45 sig_type=std_logic lab=b1b}
C {inverter1.sym} -10580 -2800 0 0 {name=x13}
C {inverter1.sym} -10950 -2800 0 0 {name=x14}
C {iopin.sym} -250 -1040 0 0 {name=p46 lab=op_1}
C {iopin.sym} -250 -940 0 0 {name=p47 lab=op_2}
C {ipin.sym} -10510 -660 0 0 {name=p48 lab=supply}
C {ipin.sym} -10360 -660 0 0 {name=p49 lab=current}
C {ipin.sym} -11470 -1140 0 0 {name=p50 lab=b8}
C {ipin.sym} -11460 -1380 0 0 {name=p51 lab=b7}
C {ipin.sym} -11470 -1690 0 0 {name=p52 lab=b6
}
C {ipin.sym} -11480 -1970 0 0 {name=p53 lab=b5
}
C {ipin.sym} -11490 -2210 0 0 {name=p54 lab=b4
}
C {ipin.sym} -11480 -2440 0 0 {name=p55 lab=b3
}
C {ipin.sym} -11480 -2680 0 0 {name=p60 lab=b2
}
C {ipin.sym} -11480 -2940 0 0 {name=p61 lab=b1
}
